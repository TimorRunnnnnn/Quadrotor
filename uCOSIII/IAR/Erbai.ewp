# IAR project Erbai.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx; NDEBUG; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED
  ICCARM.CCIncludePath2: ..\Application; ..\APP-OS; ..\BSP; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\uC-CPU; ..\uC-CPU\ARM-Cortex-M4\IAR; ..\uC-LIB; ..\uCOS-III\Source; ..\BSP\uCOS-III; ..\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\MyLib; ..\..\MyLib\Matrix\inc; ..\..\MyLib\Math\inc; ..\..\MyLib\Algorithm\inc; ..\..\MyLib\miniAHRS; ..\..\MyLib\miniIMU; ..\..\MyLib\AirNano; ..\..\MyLib\FatFs\src\drivers; ..\..\MyLib\FatFs\src\option; ..\..\MyLib\FatFs\src; ..\..\MyLib\minINI; ..\Application\FileFunction; ..\..\MyLib\miniIMU; ..\..\MyLib\EKF; ..\..\MyLib\kr_attitude_eskf-master\src; ..\..\MyLib\kr_attitude_eskf-master\src\Eigen; ..\..\MyLib\kr_attitude_eskf-master; ..\..\MyLib\MadgwickAHRS; ..\..\MyLib\UM6_State
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Erbai.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: H:\四轴代码\uCOSIII\BSP\STM32F4xx_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../MyLib/: AHRS.c AHRS.h Android.c Android.h BlueToothDTU.c BlueToothDTU.h Function.c Function.h ms5611.c ms5611.h
    ../Application/: Control.c Control.h fatfs.c Global.h Init.c Init.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h
  group Application/AirNano
    ../../MyLib/AirNano/: Algorithm_filter.c Algorithm_filter.h Algorithm_math.c Algorithm_math.h Algorithm_quaternion.c Algorithm_quaternion.h
    ../../MyLib/MadgwickAHRS/: MadgwickAHRS.c
    ../../MyLib/Algorithm/src/: Quaternion.c
  group Application/ekf
    ../../MyLib/Algorithm/dsp/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ../../MyLib/Matrix/src/: DoubleMatrix.c Matrix.c
    ../../MyLib/Algorithm/src/: EKF.c UKF.c
    ../../MyLib/Math/src/: FastMath.c
  group Application/FileFunction
    ../Application/FileFunction/: filefunction.c filefunction.h
  group Application/minINI
    ../../MyLib/minINI/: minGlue-FatFs.h minIni.c minIni.h
  group Application-OS
    ../APP-OS/: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx_hal_conf.h
  group BoardSupportPackage
    ../BSP/: bsp.c bsp.h bsp_driver_sd.c bsp_int.c bsp_periph.c cpu_bsp.c
  group BoardSupportPackage/CMSIS
    ../BSP/CMSIS/: system_stm32f4xx.c
  group BoardSupportPackage/IAR
    ../BSP/: cstartup.c
  group BoardSupportPackage/uCOS_III
    ../BSP/uCOS-III/: bsp_os.c bsp_os.h
  group Middlewares/fatfs
    ../../MyLib/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf_template.h integer.h
    ../../MyLib/FatFs/src/drivers/: sd_diskio.c sd_diskio.h
    ../../MyLib/FatFs/src/option/: syscall.c unicode.c
  group STM32CubeF4/Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f405xx.h stm32f4xx.h system_stm32f4xx.h
  group STM32CubeF4/Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group uC/CPU
    ../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M4/IAR
    ../uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS_III/Ports/ARM-Cortex-M4/Generic/IAR
    ../uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS_III/Source
    ../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
